FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-dpdk-linker-flags-zlib-and-libpcap.patch"

