OPTEEMACHINE:lx2160a-cex6 = "ls-lx2160ardb"
OPTEEMACHINE:lx2160a-cex7 = "ls-lx2160ardb"
OPTEEMACHINE:lx2162a-som = "ls-lx2160ardb"
