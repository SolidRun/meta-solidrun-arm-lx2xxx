DOCKER_PKGS =+ " skopeo "
