# Update source commit with new EULA, previous commit was deleted from GitHub.
LIC_FILES_CHKSUM = "file://NXP-Binary-EULA.txt;md5=481d6288552113961a835bbabceb0c33"
SRCREV = "73d323d2538d7fe7ae93d88c2c5c4489f5891fcb"
